#include "Panel.h"

namespace {

// 4-gray waveform for the SSD1683 on the Waveshare 4.2" V2 / GDEY042T81, from
// Waveshare's e-Paper demo (EPD_4in2_V2, LUT_ALL), as used by GxEPD2_4G:
// 227 bytes for command 0x32, then 0x3F, VGH (0x03), VSH1/VSH2/VSL (0x04) and
// VCOM (0x2C).
const uint8_t kLut4G[233] PROGMEM = {
    0x01, 0x0A, 0x1B, 0x0F, 0x03, 0x01, 0x01, 0x05, 0x0A, 0x01, 0x0A, 0x01, 0x01, 0x01,
    0x05, 0x08, 0x03, 0x02, 0x04, 0x01, 0x01, 0x01, 0x04, 0x04, 0x02, 0x00, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
    0x01, 0x0A, 0x1B, 0x0F, 0x03, 0x01, 0x01, 0x05, 0x4A, 0x01, 0x8A, 0x01, 0x01, 0x01,
    0x05, 0x48, 0x03, 0x82, 0x84, 0x01, 0x01, 0x01, 0x84, 0x84, 0x82, 0x00, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
    0x01, 0x0A, 0x1B, 0x8F, 0x03, 0x01, 0x01, 0x05, 0x4A, 0x01, 0x8A, 0x01, 0x01, 0x01,
    0x05, 0x48, 0x83, 0x82, 0x04, 0x01, 0x01, 0x01, 0x04, 0x04, 0x02, 0x00, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
    0x01, 0x8A, 0x1B, 0x8F, 0x03, 0x01, 0x01, 0x05, 0x4A, 0x01, 0x8A, 0x01, 0x01, 0x01,
    0x05, 0x48, 0x83, 0x02, 0x04, 0x01, 0x01, 0x01, 0x04, 0x04, 0x02, 0x00, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
    0x01, 0x8A, 0x9B, 0x8F, 0x03, 0x01, 0x01, 0x05, 0x4A, 0x01, 0x8A, 0x01, 0x01, 0x01,
    0x05, 0x48, 0x03, 0x42, 0x04, 0x01, 0x01, 0x01, 0x04, 0x04, 0x42, 0x00, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x02, 0x00, 0x00, 0x07, 0x17, 0x41, 0xA8, 0x32, 0x30,
};

}  // namespace

// One RAM plane: a bit is 1 where the pixel's level is in setFor (bit mask
// of levels). RAM 0x26 is set for black and dark gray, RAM 0x24 for black
// and light gray; the waveform turns the two bits into 4 grays.
void Panel::writePlane(uint8_t command, const uint8_t* levels, uint8_t setFor) {
    _writeCommand(0x4E);   // address counter to the window start
    _writeData(0);
    _writeCommand(0x4F);
    _writeData(0);
    _writeData(0);
    _writeCommand(command);
    _startTransfer();
    const uint32_t bytes = uint32_t(WIDTH) * HEIGHT / 8;
    for (uint32_t i = 0; i < bytes; i++) {
        uint8_t a = levels[2 * i], b = levels[2 * i + 1];   // 8 pixels
        uint8_t out = 0;
        for (int k = 0; k < 4; k++) out = out << 1 | ((setFor >> ((a >> (6 - 2 * k)) & 3)) & 1);
        for (int k = 0; k < 4; k++) out = out << 1 | ((setFor >> ((b >> (6 - 2 * k)) & 3)) & 1);
        _transfer(out);
    }
    _endTransfer();
}

void Panel::showGray(const uint8_t* levels) {
    if (_hibernating) _reset();
    delay(10);
    _writeCommand(0x12);   // software reset
    delay(10);
    _writeCommand(0x0C);   // soft start
    _writeData(0x8B);
    _writeData(0x9C);
    _writeData(0xA4);
    _writeData(0x0F);
    _writeCommand(0x21);
    _writeData(0x00);
    _writeData(0x00);
    _writeCommand(0x3C);   // border
    _writeData(0x03);
    _writeCommand(0x11);   // x, y increment
    _writeData(0x03);
    _writeCommand(0x44);
    _writeData(0);
    _writeData((WIDTH - 1) / 8);
    _writeCommand(0x45);
    _writeData(0);
    _writeData(0);
    _writeData((HEIGHT - 1) % 256);
    _writeData((HEIGHT - 1) / 256);
    _writeCommand(0x32);
    _writeDataPGM(kLut4G, 227);
    _writeCommand(0x3F);
    _writeData(pgm_read_byte(&kLut4G[227]));
    _writeCommand(0x03);
    _writeData(pgm_read_byte(&kLut4G[228]));
    _writeCommand(0x04);
    _writeData(pgm_read_byte(&kLut4G[229]));
    _writeData(pgm_read_byte(&kLut4G[230]));
    _writeData(pgm_read_byte(&kLut4G[231]));
    _writeCommand(0x2C);
    _writeData(pgm_read_byte(&kLut4G[232]));
    writePlane(0x26, levels, 0b0011);   // levels 0, 1
    delay(1);                            // yield between the planes
    writePlane(0x24, levels, 0b0101);   // levels 0, 2
    _writeCommand(0x21);
    _writeData(0x88);   // both RAMs inverted, as the waveform expects
    _writeData(0x00);
    _writeCommand(0x22);
    _writeData(0xCF);   // clock and analog on, show with the loaded LUT, off again
    _writeCommand(0x20);
    _waitWhileBusy("showGray", kGrayRefreshMs);
    // the registers no longer suit GxEPD2's black-and-white updates
    _power_is_on = false;
    _init_display_done = false;
}
